options:
  parameters:
    generate_options: qt_gui
    id: loratx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_UNIFORM
    mean: '1000'
    msg: pmt.intern("Hello, RPi!")
    std: '1000'
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: '500000'
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '0'
    samp_rate: '1000000'
    sf: '9'
    sync_word: '[0x12]'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    freq0: 433e6
    gain0: '25'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_message_strobe_random_0, strobe, lora_tx_0, in]
- [lora_tx_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
