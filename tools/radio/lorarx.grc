options:
  parameters:
    generate_options: qt_gui
    id: lorarx
    output_language: python
    title: LoRa RX
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1000'
    stop: 500e3
    value: 500e3
  states: {}
- name: deci
  id: variable_qtgui_range
  parameters:
    comment: Decimation
    rangeType: int
    start: '0'
    step: '1'
    stop: '25'
    value: '4'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: Frequency (Hz)
    start: 380e6
    step: 200e3
    stop: 540e6
    value: 433.5e6
  states: {}
- name: freq_cor
  id: variable_qtgui_range
  parameters:
    comment: Frequency Correction (ppm)
    rangeType: int
    start: '0'
    step: '1'
    stop: '99'
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: RF Gain (dB)
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '25'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: SDR Sample Rate
    value: 2e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-bandwidth'
    decim: deci
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 300000, 100000)
    type: ccc
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: int(bandwidth)
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '0'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: int(samp_rate/deci)
    sf: '9'
    soft_decoding: 'True'
    sync_word: '[0x12]'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '0'
    corr0: freq_cor
    dc_offset_mode0: '2'
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '0'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [freq_xlating_fir_filter_xxx_0, '0', lora_rx_0, '0']
- [lora_rx_0, out, blocks_message_debug_0, print]
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
